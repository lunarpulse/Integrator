# Keil uVision project Integrator.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Integrator
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers
    ./Drivers/: hal_gpio_driver.c hal_gpio_driver.h hal_i2c_driver.c hal_i2c_driver.h hal_spi_driver.c hal_spi_driver.h hal_uart_driver.c hal_uart_driver.h uart_debug.h imu.c imu.h servo.c servo.h
    ./App/: i2c_main.h
  group App
    ./App/: uart_main.h uart_main.c spi_slave.c spi_main.h led.h led.c intergrator.c i2c_main.c i2c_int_handler.c i2c_main.h
  group lib
    ./lib/: uartdebug.lib
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
